# Keil uVision project MT02.uvproj.uvproj, settings and files
target MT02 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MT02 +hex
  c flags: Optim=1
  c include: .\inc;.\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group StartUp
    ./: startup_stm32f10x_md.s
  group MT02_lib
    ./MX02_stblib/: cc10x_adc.c cc10x_bkp.c cc10x_can.c cc10x_comp.c cc10x_crc.c cc10x_dac.c cc10x_exti.c cc10x_flash.c cc10x_gpio.c cc10x_i2c.c cc10x_iwdg.c cc10x_opamp.c cc10x_pwr.c cc10x_rcc.c cc10x_rtc.c cc10x_spi.c cc10x_tim.c cc10x_usart.c cc10x_wwdg.c misc.c cc10x_dma.c
  group bsp
    ./bsp/: main.c gpio_test.c
